# Keil uVision project SP37 Empty Project.uvproj, settings and files
target CustomerProject (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: TARGET +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: main.c STARTUP.A51 SP37_DevLib.c
  group Header
    ./: SP37_DevLib.h Reg_SP37.h SP37_ROMLibrary.h
  group MISC
    ./: C51S.LIB SP37_ROMLibrary.LIB
