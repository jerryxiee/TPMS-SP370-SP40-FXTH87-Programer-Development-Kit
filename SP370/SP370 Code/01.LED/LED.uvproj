# Keil uVision project LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: LED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\INCLUDE
  group USER
    ./USER/: main.c STARTUP.A51
  group INCLUDE
    ./INCLUDE/: Reg_SP37.h
