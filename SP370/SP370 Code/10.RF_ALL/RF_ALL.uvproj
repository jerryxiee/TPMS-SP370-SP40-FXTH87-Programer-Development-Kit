# Keil uVision project RF_ALL.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: RF_ALL +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group USER
    ./user/: RF.c SP37.c STARTUP.A51 main.c uart.c
  group INCLUDE
    ./include/: Reg_SP37.h RF.h SP37.h SP37_ROMLibrary.h SP37_ROMLibrary.LIB uart.h
