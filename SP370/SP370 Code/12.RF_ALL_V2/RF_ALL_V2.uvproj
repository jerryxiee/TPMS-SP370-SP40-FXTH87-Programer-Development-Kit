# Keil uVision project RF_ALL_V2.uvproj, settings and files
target RF_ALL_V2 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: RF_ALL_V2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group USER
    ./user/: main.c RF.c SP37.c uart.c STARTUP.A51
  group INCLUDE
    ./include/: Reg_SP37.h RF.h SP37.h SP37_ROMLibrary.h SP37_ROMLibrary.LIB uart.h
