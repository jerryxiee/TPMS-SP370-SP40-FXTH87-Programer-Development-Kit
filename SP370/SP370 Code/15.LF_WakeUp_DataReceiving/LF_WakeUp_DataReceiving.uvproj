# Keil uVision project LF_WakeUp_DataReceiving.uvproj, settings and files
target LF_WakeUp_DataReceiving (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: LF_WakeUp_DataReceiving +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group USER
    ./user/: LF.c main.c RF.c SP37.c STARTUP.A51 uart.c
  group INCLUDE
    ./include/: LF.h Reg_SP37.h RF.h SP37.h SP37_ROMLibrary.h SP37_ROMLibrary.LIB uart.h
