# Keil uVision project SP37_RFData_To_OLED_WithCRC_V2.uvprojx, settings and files
target SP37_RFData_To_OLED_WithCRC_V2 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SP37_RFData_To_OLED_WithCRC_V2 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\CORE;..\FWLib\inc;.\INCLUDE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./User/: clock.c CRC.c delay.c display.c iic1.c led.c main.c mysprintf.c oled.c SP37Data.c spi.c stm32f10x_it.c sys.c system_stm32f10x.c TDA5235.c tim.c usart.c
  group INCLUDE
    ./INCLUDE/: clock.h CRC.h delay.h display.h iic1.h led.h mysprintf.h oled.h oledfont.h SP37Data.h spi.h stm32f10x.h stm32f10x_conf.h stm32f10x_it.h sys.h system_stm32f10x.h TDA5235.h TDA5235_SFR.h TDA5235_SFR_INIT.h tim.h usart.h
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ./CORE/: core_cm3.c core_cm3.h startup_stm32f10x_md.s
